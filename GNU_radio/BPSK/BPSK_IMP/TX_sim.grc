options:
  parameters:
    generate_options: qt_gui
    id: TX
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: bpsk
  id: variable_constellation_rect
  parameters:
    comment: 'Symbol map: [0, 1] is Gray coded'
    const_points: '[-0.707-0j, 0.707+0j]'
    imag_sect: '2'
    real_sect: '2'
    rot_sym: '4'
    sym_map: '[0, 1]'
    w_imag_sect: '1'
    w_real_sect: '1'
  states: {}
- name: delay
  id: variable_qtgui_range
  parameters:
    comment: |-
      This is used to align
      the transmitter and 
      received bitstreams
    label: Delay
    start: '0'
    step: '1'
    stop: '1000'
    value: '52'
  states: {}
- name: epsilon
  id: variable_qtgui_range
  parameters:
    comment: |-
      Sets timing difference
      between transmitter
      and receiver due to 
      variations in clocks
    label: 'Channel: Timing Offset'
    start: '0.999'
    step: '100e-6'
    stop: '1.001'
    value: '1.0005'
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.350'
  states: {}
- name: freq_offset
  id: variable_qtgui_range
  parameters:
    comment: |-
      This accounts for differences
      in local oscillatiors as well as
      static Doppler shift
    label: 'Channel: Frequency Offset'
    start: '-0.100'
    step: '0.001'
    stop: '0.100'
    value: '0.10'
  states: {}
- name: noise_volt
  id: variable_qtgui_range
  parameters:
    comment: |-
      Noise level of AAWGN added 
      during transmission as well as 
      antenna noise and LNA of receiver.
      in real case we dont need this?
    label: 'Channel: Noise Voltage'
    start: '0'
    step: '0.10'
    stop: '1'
    value: '0.200'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, excess_bw, 45)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: variable_0
  id: variable
  parameters:
    value: '0'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: /home/anna/Projects/adaptive_rf/GNU_radio/BPSK/BPSK_IMP/message.bin
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_throttle2_0
  id: blocks_throttle2
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    epsilon: epsilon
    freq_offset: freq_offset
    noise_voltage: noise_volt
    seed: '0'
    taps: '1.0'
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: filter_fft_rrc_filter_0
  id: filter_fft_rrc_filter
  parameters:
    alpha: excess_bw
    decim: '1'
    gain: '1'
    ntaps: 11*sps
    samp_rate: samp_rate
    sym_rate: '8000'
    type: ccc
  states: {}
- name: fir_filter_xxx_0
  id: fir_filter_xxx
  parameters:
    decim: '1'
    taps: rrc_taps
    type: ccc
  states: {}
- name: iio_pluto_sink_0
  id: iio_pluto_sink
  parameters:
    attenuation1: '10.0'
    bandwidth: '20000000'
    buffer_size: '32768'
    cyclic: 'False'
    filter_source: '''Auto'''
    frequency: '2400000000'
    samplerate: samp_rate
    type: fc32
    uri: ip:192.168.2.1
  states: {}
- name: qtgui_const_sink_x_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_const_sink_x_0_0
  id: qtgui_const_sink_x
  parameters:
    size: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_freq_sink_x_0_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '200'
    srate: samp_rate
    type: complex
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    size: '200'
    srate: samp_rate
    type: complex
  states: {}

connections:
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [blocks_throttle2_0, '0', channels_channel_model_0, '0']
- [channels_channel_model_0, '0', filter_fft_rrc_filter_0, '0']
- [channels_channel_model_0, '0', fir_filter_xxx_0, '0']
- [digital_constellation_modulator_0, '0', blocks_throttle2_0, '0']
- [digital_constellation_modulator_0, '0', iio_pluto_sink_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_const_sink_x_0_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_freq_sink_x_0_0, '0']
- [filter_fft_rrc_filter_0, '0', qtgui_time_sink_x_0_0, '0']
- [fir_filter_xxx_0, '0', qtgui_const_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_freq_sink_x_0, '0']
- [fir_filter_xxx_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
