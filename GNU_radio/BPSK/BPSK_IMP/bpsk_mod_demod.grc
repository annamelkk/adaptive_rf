options:
  parameters:
    generate_options: qt_gui
    id: bpsk_demod
    output_language: python
    title: bpsk_stage1
  states: {}

blocks:
- name: bpdk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: bpsk
  id: variable_constellation
  parameters:
    precision: '8'
    type: bpsk
  states: {}
- name: excess_bw
  id: variable
  parameters:
    value: '0.35'
  states: {}
- name: loop_bw
  id: variable
  parameters:
    value: '0.0628'
  states: {}
- name: rrc_taps
  id: variable
  parameters:
    value: firdes.root_raised_cosine(1, sps, 1, excess_bw, 45)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: sps
  id: variable
  parameters:
    value: '4'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: C:\Users\Admin\Desktop\adaptive_rf\GNU_radio\BPSK\BPSK_IMP\test.bin
    type: byte
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: C:\Users\Admin\Desktop\adaptive_rf\GNU_radio\BPSK\BPSK_IMP\message.bin
    repeat: 'False'
    type: byte
  states: {}
- name: blocks_pack_k_bits_bb_0
  id: blocks_pack_k_bits_bb
  parameters:
    k: '8'
  states: {}
- name: digital_constellation_decoder_cb_0
  id: digital_constellation_decoder_cb
  parameters:
    constellation: bpsk
  states: {}
- name: digital_constellation_modulator_0
  id: digital_constellation_modulator
  parameters:
    constellation: bpsk
    differential: 'True'
    excess_bw: excess_bw
    samples_per_symbol: sps
  states: {}
- name: digital_diff_decoder_bb_0
  id: digital_diff_decoder_bb
  parameters:
    coding: digital.DIFF_DIFFERENTIAL
    modulus: '2'
  states: {}
- name: epy_block_0
  id: epy_block
  parameters:
    _source_code: |-
      import time
      import struct
      import binascii
      import numpy as np
      from gnuradio import gr


      class blk(gr.sync_block):
          """Finds the sync word in a bit stream, then decodes length + text + CRC16."""

          def __init__(self, sync_hex="1ACFFC1D"):
              gr.sync_block.__init__(self, name="Frame Decoder",
                                     in_sig=[np.uint8], out_sig=None)
              sync_bits = np.unpackbits(np.frombuffer(bytes.fromhex(sync_hex), dtype=np.uint8))
              self.sync_pm = 2 * sync_bits.astype(np.int16) - 1   # +1/-1 pattern
              self.n = len(sync_bits)
              self.buf = np.zeros(0, dtype=np.uint8)
              self.good = 0
              self.bad = 0
              self.total = 0
              self.last_print = 0.0
              self.last_status = time.time()

          def work(self, input_items, output_items):
              x = input_items[0]
              self.total += len(x)
              self.buf = np.concatenate((self.buf, x & 1))
              self._scan()
              if time.time() - self.last_status > 1.0:
                  self.last_status = time.time()
                  print("[status] bits=%d good=%d bad=%d" % (self.total, self.good, self.bad))
              return len(x)

          def _scan(self):
              n = self.n
              while len(self.buf) >= n:
                  s = 2 * self.buf.astype(np.int16) - 1
                  c = np.correlate(s, self.sync_pm, mode="valid")
                  hits = np.where(np.abs(c) >= n - 2)[0]      # allows 1 bit error
                  if len(hits) == 0:
                      self.buf = self.buf[-(n - 1):]
                      return
                  h = hits[0]
                  start = h + n
                  if len(self.buf) < start + 8:               # wait for more bits
                      self.buf = self.buf[h:]
                      return
                  bits = self.buf[start:]
                  if c[h] < 0:                                # inverted polarity
                      bits = 1 - bits
                  length = int(np.packbits(bits[:8])[0])
                  total = 8 + 8 * length + 16                 # length + payload + CRC
                  if len(bits) < total:
                      self.buf = self.buf[h:]
                      return
                  data = np.packbits(bits[:total]).tobytes()
                  body = data[:-2]
                  crc = struct.unpack(">H", data[-2:])[0]
                  if crc == binascii.crc_hqx(body, 0xFFFF):
                      self.good += 1
                      self.buf = self.buf[start + total:]
                      if time.time() - self.last_print > 0.5:
                          self.last_print = time.time()
                          text = body[1:].decode("ascii", errors="replace")
                          print("[good %d, bad %d] %s" % (self.good, self.bad, text))
                  else:
                      self.bad += 1
                      self.buf = self.buf[h + 1:]
    sync_hex: '   "1ACFFC1D"'
  states: {}

connections:
- [blocks_file_source_0, '0', digital_constellation_modulator_0, '0']
- [blocks_pack_k_bits_bb_0, '0', blocks_file_sink_0, '0']
- [digital_constellation_decoder_cb_0, '0', digital_diff_decoder_bb_0, '0']
- [digital_constellation_modulator_0, '0', digital_constellation_decoder_cb_0, '0']
- [digital_diff_decoder_bb_0, '0', blocks_pack_k_bits_bb_0, '0']
- [digital_diff_decoder_bb_0, '0', epy_block_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
